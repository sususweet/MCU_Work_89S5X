ORG 0000H
MOV R0,#00H ;行选标志位
MOV R1,#00H ;当前查表标志位
MOV R2,#00H ;滚动延时标志位,修改R2可以调整滚动速度
MOV R3,#00H ;滚动偏移标志位

MOV DPTR,#WORD
;MOV P1,R0
;MOV P0,#0FFH
;MOV P2,#0FFH
;SJMP $
LOOP1:
     CJNE R3,#60H,LOOP
     MOV R3,#00H
     MOV DPTR,#WORD
LOOP:
     MOV P1,R0

     ;MOV A,R1
     ;ADD A,R2
     ;MOV R1,A

     MOV A,R1
     MOVC A,@A+DPTR
     MOV P2,A
     INC R1
     ;MOV A,#0FFH
     ;MOV P2,A

     MOV A,R1
     MOVC A,@A+DPTR
     MOV P0,A
     INC R1
     INC R0
     
     INC R2
     ;MOV A,#01H
     ;MOV P0,A
     CJNE R0,#10H,GOON
     CJNE R2,#10H,GOON2
     INC DPTR
     INC DPTR
     
     INC R3
     
     MOV R0,#00H
     MOV R1,#00H
     MOV R2,#00H
     AJMP LOOP1
GOON2:
    MOV R0,#00H
    MOV R1,#00H
GOON:
    LCALL DELAY
    AJMP LOOP
WORD: DB 00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H
      DB 00H,00H,00H,00H,00H,00H,00H,00H
      DB 080H,000H,000H,001H,0FCH,07FH,004H,001H,0F4H,01FH,004H,011H,0FCH,07FH,004H,011H,0F4H,01FH,004H,001H,0F4H,01FH,014H,010H;
      DB 012H,010H,012H,010H,0F1H,01FH,010H,010H;"唐",0

      DB 00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H
      DB 00H,00H,00H,00H,00H,00H,00H,00H
      DB 080H,008H,084H,008H,0E8H,07FH,088H,008H,001H,000H,0F2H,07FH,012H,040H,008H,000H,0E8H,03FH,004H,002H,007H,002H,0C4H,01FH;
      DB 004H,00AH,004H,012H,0F4H,07FH,000H,000H;"滢",0

      DB 00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H
      DB 00H,00H,00H,00H,00H,00H,00H,00H
      DB 080H,010H,084H,010H,0E8H,07FH,088H,010H,081H,010H,082H,01FH,092H,010H,090H,010H,088H,01FH,088H,010H,087H,010H,0E4H,07FH;
      DB 004H,000H,004H,009H,084H,010H,040H,020H;"淇",0

      DB 00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H,00H
      DB 00H,00H,00H,00H,00H,00H,00H,00H
DELAY:
       mov r5,#20
       d1:mov r6,#5
       d2:mov r7,#5
       djnz r7,$
       djnz r6,d2
       djnz r5,d1
       ret